Commit message: Bug-fix for boxerFk.

File: src/forwardKinematics/urdfFks/urdf/boxer.urdf (robot description, URDF)
Before this commit: robot albert, 5 links, 4 joints
Joints:
- joint ee_joint: origin xyz=0.6 0 0 rpy=0 0 0 -> xyz=0 -0.4 0 rpy=0 0 0
